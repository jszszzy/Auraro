# Repository jszszzy/Auraro

File README.md:

# Auraro

#### 介绍
​	为了不重复造轮子，通过高密度M.2接口设计板卡，欢迎各位复现，提出意见，更欢迎推出不同芯片的版卡、不同功能的底板。

#### 软件使用推荐

KiCAD 6.0 [ PCB ]:[下载地址](https://www.kicad.org/)

Blender 3.0 [ 3D  ]

#### 硬件架构
M.2/NGFF : A B E M B+M 四种型号。

推荐设计符合NGFF规范，从而实现板卡间的兼容。

NGFF 规范文档：见Docs目录下。

现有芯片支持：

- STM32-LQFP48(All_Suppoort) -- NGFF_2230
- ESP-C3 -- NGFF_2230
- STM32-LQFP32(All_Suppoort) -- NGFF_2220

#### 使用说明

​	 现阶段因为两个板子都是刚刚打板，没有进行完全测试，为了每个板子都能完美正常工作，会出一个完备测试的流程，通过测试即可提交。

如果你没有安装KiCAD，请使用bom下的preview.html直接可以查看板子信息。

目前状态：

测试底板已更新，typec正反插可切换USB和串口通信。

目前已有板卡展示：

STM32_LQFP64：

STM32_LQFP64：

STM32_LQFP32：

测试底板：

#### 提示

如果你又没安装Kicad，请使用bom下的preview.html直接可以查看板子信息。

#### 参与贡献

1.  Fork 本仓库
2.  新建 Feat_xxx 分支
3.  提交代码
4.  新建 Pull Request

## KiCad design Test_Board/Test_Board.kicad_pcb

Parts:
C1: 100NF; C_0603_1608Metric
C3: 10UF; C_0603_1608Metric
CN1: APCI0108-P001A; CONN-SMD_APCI0108-P001A
D1: LED; LED_0603_1608Metric
J1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical_SMD_Pin1Left
J2, J4: Conn_02x11_Top_Bottom; PinHeader_2x11_P2.54mm_Horizontal
J3: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
R1: 1K; R_0603_1608Metric
R2, R3: 5.1k; R_0402_1005Metric
U1: CH340E; MSOP-10_3x3mm_P0.5mm
U2: ME6217C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR

Connections:
+3V3: CN1.2, CN1.4, CN1.72, CN1.74, D1.2 (A), J1.1, U2.5 (VOUT)
/PA0: CN1.53, J2.11
/PA1: CN1.49, J2.9
/PA2: CN1.47, J2.7
/PA3: CN1.43, J2.5
/PA4: CN1.41, J2.3
/PA5: CN1.37, J4.19
/PA6: CN1.35, J4.17
/PA7: CN1.23, J4.15
/PA8: CN1.32, J4.18
/PA9: CN1.34, J4.20, U1.9 (RXD)
/PA10: CN1.36, J4.22, U1.8 (TXD)
/PA13/SWDIO: CN1.38, J1.3
/PA14/SWCLK: CN1.40, J1.2
/PA15: CN1.42, J4.21
/PB0: CN1.17, J4.9
/PB1: CN1.15, J4.7
/PB2: CN1.13, J4.5
/PB3: CN1.52, J2.10
/PB4: CN1.54, J2.12
/PB5: CN1.56, J2.14
/PB6: CN1.58, J2.16
/PB7: CN1.60, J2.18
/PB8: CN1.62, J2.20
/PB9: CN1.64, J2.22
/PB10: CN1.11, J4.3
/PB11: CN1.9, J4.1
/PB12: CN1.6, J4.2
/PB13: CN1.8, J4.4
/PB14: CN1.10, J4.6
/PB15: CN1.12, J4.8
/PC0: CN1.71, J2.19
/PC1: CN1.61, J2.17
/PC2: CN1.59, J2.15
/PC3: CN1.55, J2.13
/PC4: CN1.21, J4.13
/PC5: CN1.19, J4.11
/PC6: CN1.14, J4.10
/PC7: CN1.16, J4.12
/PC8: CN1.20, J4.14
/PC9: CN1.22, J4.16
/PC10: CN1.44, J2.2
/PC11: CN1.46, J2.4
/PC12: CN1.48, J2.6
/PC13: CN1.73, J2.21
/PD2: CN1.50, J2.8
/UD+: J3.A6 (D+), U1.1 (UD+)
/UD-: J3.A7 (D-), U1.2 (UD-)
/USB_D+: CN1.3, J3.B6 (D+)
/USB_D-: CN1.5, J3.B7 (D-)
/VBATIN: CN1.70
GND: C1.1, C3.1, CN1.1, CN1.7, CN1.18, CN1.33, CN1.39, CN1.45, CN1.51, CN1.57, CN1.63, CN1.69, CN1.75, J1.4, J2.1, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R1.2, R2.1, R3.1, U1.3 (GND), U2.2 (VSS)
unnamed: C3.2, U1.10 (V3)
unnamed: D1.1 (K), R1.1
unnamed: J3.A5 (CC1), R2.2
unnamed: J3.B5 (CC2), R3.2
VBUS: C1.2, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U1.7 (VCC), U2.1 (VIN), U2.3 (CE)

Notes on the sheet:
C1 WITH HIGH VOLTAGE WITHSTANDING
M.2接口
Type_C USB
USB TO TTL UART USB转串口
Connector 排针
电源 POWER SUPPLY 5V -> 3.3V
电源指示灯 3.3V POWER LED 5V -> 3.3V
SW模式下载端口

Board: 4 copper layers, 24.0 x 38.4 mm, 12 parts (11 on the bottom side), 54 nets.

## KiCad design STM32_LQFP32/STMF030_M.2/STM32_FOC_Board/STM32_FOC_Board.kicad_pcb

Parts:
C1, C11: 10UF; C_0603_1608Metric
C2: 100NF; C_0402_1005Metric
C3: 4.7UF; C_0402_1005Metric
C4: 10NF; C_0402_1005Metric
C5, C6: 1UF; C_0402_1005Metric
C7, C8, C9, C10: NOT DEFINE; C_0402_1005Metric
D1, D2: BAT60A; D_SOD-323
D3, D5: LED; LED_0603_1608Metric
D4: BZD27Cxx; D_SMF
F1: Fuse; Fuse_0603_1608Metric
J1: Bus_M.2_Socket_E; NGFF_E
R1, R3: 4.7K; R_0402_1005Metric
R2: 0R; R_0603_1608Metric
R4: 1K; R_0402_1005Metric
R5, R6: 0; R_0402_1005Metric
R7: 1K; R_0603_1608Metric
SW1, SW2: TS24CA; SW-SMD_TS24CA
U1: STM32F030C6Tx; LQFP-48_7x7mm_P0.5mm
U2: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm
X1: FC-12M32.768KHZ7PF20PPM; FC-12M_L2.0-W1.2
X2: 7R24000E12UBE; OSC-SMD_4P-L2.5-W2.0-BL.kicad_mod

Connections:
+3.3VA: F1.1, J1.2 (3.3V), J1.4 (3.3V), J1.72 (3.3V), J1.74 (3.3V)
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C11.1, D1.2 (A), D4.2 (A), D5.2 (A), F1.2, R3.1, R5.2, SW1.4, U1.9 (VDDA), U1.24 (VDD), U1.48 (VDD), U2.3 (IO2), U2.7 (IO3), U2.8 (VCC)
/BOOT0: R1.1, SW1.3, U1.44 (BOOT0)
/CS: U2.1 (~CS)
/NRST: R3.2, SW2.4, U1.7 (NRST)
/PA0: J1.53 (~CLKREQ0), U1.10 (PA0)
/PA1: J1.49 (REFCLKn0), U1.11 (PA1)
/PA2: J1.47 (REFCLKp0), U1.12 (PA2)
/PA3: J1.43 (PERn0), U1.13 (PA3)
/PA4: J1.41 (PERp0), U1.14 (PA4)
/PA5: J1.37 (PETn0), U1.15 (PA5)
/PA6: J1.35 (PETp0), U1.16 (PA6)
/PA7: J1.23 (~SDIO_RESET), U1.17 (PA7)
/PA8: J1.32 (UART_TXD), U1.29 (PA8)
/PA9: J1.34 (UART_CTS), U1.30 (PA9)
/PA10: J1.36 (UART_RTS), U1.31 (PA10)
/PA13: U1.34 (PA13)
/PA14: J1.38 (VENDOR_DEFINED), U1.37 (PA14)
/PA15: J1.40 (VENDOR_DEFINED), U1.38 (PA15)
/PB0: J1.17 (SDIO_DATA2), U1.18 (PB0)
/PB1: J1.15 (SDIO_DATA1), U1.19 (PB1)
/PB2: J1.13 (SDIO_DATA0), U1.20 (PB2)
/PB3: J1.50 (SUSCLK), U1.39 (PB3), U2.6 (CLK)
/PB4: J1.52 (~PERST0), U1.40 (PB4), U2.2 (DO(IO1))
/PB5: J1.54 (~W_DISABLE2), U1.41 (PB5), U2.5 (DI(IO0))
/PB6: J1.56 (~W_DISABLE1), U1.42 (PB6)
/PB7: J1.60 (I2C_CLK), U1.43 (PB7)
/PB8: J1.62 (~ALERT), U1.45 (PB8)
/PB9: J1.64 (RESERVED), U1.46 (PB9)
/PB10: J1.11 (SDIO_CMD), U1.21 (PB10)
/PB11: J1.9 (SDIO_CLK), U1.22 (PB11)
/PB12: J1.6 (~LED_1), U1.25 (PB12)
/PB13: J1.8 (PCM_CLK/I2S_SCK), U1.26 (PB13)
/PB14: J1.10 (PCM_SYNC/I2S_WS), U1.27 (PB14)
/PB15: J1.12 (PCM_IN/I2S_SD_IN), U1.28 (PB15)
/PC13: J1.73 (RESERVED/REFCLKn1), R4.1, U1.2 (PC13)
/PC14: C7.1, U1.3 (PC14), X1.1 (OSC1)
/PC15: C9.1, U1.4 (PC15), X1.2 (OSC2)
/PF0: C10.1, U1.5 (PF0), X2.3 (OSC2)
/PF1: C8.1, U1.6 (PF1), X2.1 (OSC1)
/PF6: J1.19 (SDIO_DATA3), R6.1, U1.35 (PF6)
/PF7: J1.21 (~SDIO_WAKE), R5.1, U1.36 (PF7)
/USB_D+: J1.3 (USB_D+), U1.33 (PA12)
/USB_D-: J1.5 (USB_D-), U1.32 (PA11)
/VBAT: C6.1, D1.1 (K), D2.1 (K), U1.1 (VDD)
/VBAT_IN: D2.2 (A), J1.70 (UIM_POWER_SRC/GPIO1/~PEWAKE1)
GNDA: C4.2, C5.2, R2.1, U1.8 (VSSA)
GNDD: C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D3.1 (K), D4.1 (K), J1.1 (GND), J1.7 (GND), J1.18 (GND), J1.33 (GND), J1.39 (GND), J1.45 (GND), J1.57 (GND), J1.63 (GND), J1.69 (GND), J1.75 (GND), R1.2, R2.2, R6.2, R7.2, SW2.3, U1.23 (VSS), U1.47 (VSS), U2.4 (GND), X2.2 (GND), X2.4 (GND)
unnamed: D3.2 (A), R4.2
unnamed: D5.1 (K), R7.1

Notes on the sheet:
CAPS PART
NGFF/M.2 E_KEY PART
R5 is 100nf R6 is 10nf
STM32F0XXXXTX :
POWER AND CONNECTER
WITH HIGH VOLTAGE WITHSTANDING
For
STM32(F1/F3)(01/02/03)XXTX STM32(L0/L1/L4/L5)XXTX STM32U5XXXXXT :
MCU CORE PART
VBUS WITH HIGH VOLTAGE WITHSTANDING

Board: 4 copper layers, 22.0 x 24.0 mm, 31 parts (5 on the bottom side), 48 nets.

## KiCad design STM32_LQFP64/STM32_LQFP64/STM32_FOC_Board.kicad_pcb

Parts:
C1, C2, C13: 10UF; C_0603_1608Metric
C3, C12, C14, C15, C16: 100NF; C_0402_1005Metric
C4: 10NF; C_0402_1005Metric
C5, C8: NOT DEFINE; C_0402_1005Metric
C6, C10: 18PF; C_0402_1005Metric
C7, C9: 1UF; C_0402_1005Metric
C11: NOT SURE; C_0402_1005Metric
D1, D2: BAT60A; D_SOD-323
D3, D5: LED; LED_0603_1608Metric
D4: BZD27Cxx; D_SMF
F1: Fuse; Fuse_0603_1608Metric
J1: Bus_M.2_Socket_E; NGFF_E
R1, R3: 4.7K; R_0603_1608Metric
R2: 0R; R_0603_1608Metric
R4, R7: 1K; R_0603_1608Metric
R5, R6: NOT SURE; R_0402_1005Metric
SW1, SW2: TS342A2P-WZ; SW-SMD_L4.0-W2.9-LS5.0
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2: ME6217C33M5G; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR
USB1: U-F-M5DD-Y-1; MICRO-USB-SMD_U-F-M5DD-Y-1
X1: FC-12M32.768KHZ7PF20PPM; FC-12M_L2.0-W1.2
X2: 7R24000E12UBE; CRYSTAL-SMD_4P-L1.6-W1.2-BL

Connections:
+3V3: C1.1, C3.1, C4.1, C7.1, C14.1, C15.1, C16.1, D1.2 (A), D5.2 (A), J1.2 (3.3V), J1.4 (3.3V), J1.72 (3.3V), J1.74 (3.3V), R3.1, SW1.1, U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.5 (VOUT)
/BOOT0: R1.1, SW1.2, U1.60 (BOOT0)
/ID: USB1.4 (ID)
/NRST: R3.2, SW2.1, U1.7 (NRST)
/PA0: J1.53 (~CLKREQ0), U1.14 (PA0)
/PA1: J1.49 (REFCLKn0), U1.15 (PA1)
/PA2: J1.47 (REFCLKp0), U1.16 (PA2)
/PA3: J1.43 (PERn0), U1.17 (PA3)
/PA4: J1.41 (PERp0), U1.20 (PA4)
/PA5: J1.37 (PETn0), U1.21 (PA5)
/PA6: J1.35 (PETp0), U1.22 (PA6)
/PA7: J1.23 (~SDIO_RESET), U1.23 (PA7)
/PA8: D3.2 (A), J1.32 (UART_TXD), U1.41 (PA8)
/PA9: J1.34 (UART_CTS), U1.42 (PA9)
/PA10: J1.36 (UART_RTS), U1.43 (PA10)
/PA13: J1.38 (VENDOR_DEFINED), U1.46 (PA13)
/PA14: J1.40 (VENDOR_DEFINED), U1.49 (PA14)
/PA15: J1.42 (VENDOR_DEFINED), U1.50 (PA15)
/PB0: J1.17 (SDIO_DATA2), U1.26 (PB0)
/PB1: J1.15 (SDIO_DATA1), U1.27 (PB1)
/PB2: J1.13 (SDIO_DATA0), U1.28 (PB2)
/PB3: J1.52 (~PERST0), U1.55 (PB3)
/PB4: J1.54 (~W_DISABLE2), U1.56 (PB4)
/PB5: J1.56 (~W_DISABLE1), U1.57 (PB5)
/PB6: J1.58 (I2C_DATA), U1.58 (PB6)
/PB7: J1.60 (I2C_CLK), U1.59 (PB7)
/PB8: J1.62 (~ALERT), U1.61 (PB8)
/PB9: J1.64 (RESERVED), U1.62 (PB9)
/PB10: J1.11 (SDIO_CMD), U1.29 (PB10)
/PB11: C11.1, J1.9 (SDIO_CLK), U1.30 (VCAP_1)
/PB12: J1.6 (~LED_1), U1.33 (PB12)
/PB13: J1.8 (PCM_CLK/I2S_SCK), U1.34 (PB13)
/PB14: J1.10 (PCM_SYNC/I2S_WS), U1.35 (PB14)
/PB15: J1.12 (PCM_IN/I2S_SD_IN), U1.36 (PB15)
/PC0: J1.71 (RESERVED/REFCLKp1), U1.8 (PC0)
/PC1: J1.61 (RESERVED/PETn1), U1.9 (PC1)
/PC2: J1.59 (RESERVED/PETp1), U1.10 (PC2)
/PC3: J1.55 (~PEWAKE0), U1.11 (PC3)
/PC4: J1.21 (~SDIO_WAKE), U1.24 (PC4)
/PC5: J1.19 (SDIO_DATA3), U1.25 (PC5)
/PC6: J1.14 (PCM_OUT/I2S_SD_OUT), U1.37 (PC6)
/PC7: J1.16 (~LED_2), U1.38 (PC7)
/PC8: J1.20 (~UART_WAKE), U1.39 (PC8)
/PC9: J1.22 (UART_RXD), U1.40 (PC9)
/PC10: J1.44 (COEX3), U1.51 (PC10)
/PC11: J1.46 (COEX2), U1.52 (PC11)
/PC12: J1.48 (COEX1), U1.53 (PC12)
/PC13: J1.73 (RESERVED/REFCLKn1), U1.2 (PC13)
/PC14: C5.1, U1.3 (PC14), X1.1 (OSC1)
/PC15: C8.1, U1.4 (PC15), X1.2 (OSC2)
/PD2: J1.50 (SUSCLK), U1.54 (PD2)
/PH0: C10.1, U1.5 (PH0), X2.3 (OSC2)
/PH1: C6.1, U1.6 (PH1), X2.1 (OSC1)
/PIN31: R5.1, U1.31 (VSS)
/PIN47: R6.1, U1.47 (VSS)
/USB_D+: J1.3 (USB_D+), U1.45 (PA12), USB1.3 (D+)
/USB_D-: J1.5 (USB_D-), U1.44 (PA11), USB1.2 (D-)
/VBAT: C9.1, D1.1 (K), D2.1 (K), U1.1 (VBAT)
/VBAT_IN: D2.2 (A), J1.70 (UIM_POWER_SRC/GPIO1/~PEWAKE1)
GNDA: C4.2, C7.2, R2.1, U1.12 (VSSA)
GNDD: C1.2, C2.2, C3.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, D4.1 (K), J1.1 (GND), J1.7 (GND), J1.18 (GND), J1.33 (GND), J1.39 (GND), J1.45 (GND), J1.63 (GND), J1.69 (GND), J1.75 (GND), R1.2, R2.2, R4.2, R5.2, R6.2, R7.2, SW2.2, U1.18 (VSS), U1.63 (VSS), U2.2 (VSS), USB1.5 (GND), USB1.6 (EP), USB1.7 (EP), USB1.8 (EP), USB1.9 (EP), X2.2 (GND), X2.4 (GND)
unnamed: D3.1 (K), R4.1
unnamed: D5.1 (K), R7.1
VBUS: F1.1, USB1.1 (VBUS)
VCC: C2.1, C12.2, C13.1, D4.2 (A), F1.2, U2.1 (VIN), U2.3 (CE)

Notes on the sheet:
CAPS PART
NGFF/M.2 E_KEY PART
C11 is 4.7UF
STM32F405/F415 :
WITH HIGH VOLTAGE WITHSTANDING
R6 is 0ohm
R6 is replaced with 2.2UF CAP
POWER AND CONNECTER
For
STM32F401xx STM32F410xx STM32F411xx STM32F412xx STM32F413xx STM32F423xx STM32F446xx :
MCU CORE PART
R5 is replaced with 2.2UF CAP
C11 is NOT CONNNECT
VBUS WITH HIGH VOLTAGE WITHSTANDING
R5 is 0ohm

Board: 4 copper layers, 22.0 x 30.1 mm, 37 parts (2 on the bottom side), 64 nets.

## Commit log

2022-01-30 first test
2022-01-30 English update
2022-02-21 "restore the PA13 and relayout"
2022-02-21 "delet the false version"
2022-04-02 "UPDATE LQFP32 AND LQFP64"
2022-04-02 "UPDATE TESTBOARD"
2022-04-02 "UPDATE KIACD"
2022-04-02 "update preview"
2022-04-04 update L431
2022-04-04 update L051
2022-04-04 update pdf
